# Keil uVision project small quadrotor.uvprojx, settings and files
target micro quadrotor (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: small quadrotor
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BMP280_API, BMP280,STM32F40_41xxx, ARM_MATH_CM4, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000, __FPU_PRESENT=1
  c include: .\Lib;.\RTE\Device\STM32F411CEUx;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: bmp280.c bmp280.h bmp280_support.c main.c spi.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:TIM 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 2.1.0
